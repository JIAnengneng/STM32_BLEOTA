# Keil uVision project IAP.uvprojx, settings and files
target STM32100E-EVAL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32100E_EVAL, STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: common.c download.c main.c stm32f10x_it.c ymodem.c upload.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c misc.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32f10x.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
  group MDK-ARM
    ./: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s startup_stm32f10x_hd_vl.s
  group Doc
    ../: readme.txt
target STM3210E-EVAL_XL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL_XL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM3210E_EVAL, STM32F10X_XL, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target STM32100B-EVAL (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32100B-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32100B_EVAL, STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210C-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM3210E_EVAL, STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM3210B_EVAL, STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0
